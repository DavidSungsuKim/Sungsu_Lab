# IAR project uCOS-III-Ex1.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F401xE ST STM32F401xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F401xE; USE_STM32F4XX_NUCLEO
  ICCARM.CCIncludePath2: ; ..\BSP; ..\BSP\IAR; ..\BSP\ST\STM32F4xx\inc; ..\BSP\ST\STM32F4xx\src; ..\..\..\Micrium\uC-CPU; ..\..\..\Micrium\uC-LIB; ..\..\..\Micrium\uC-CPU\ARM-Cortex-M4\IAR; ..\..\..\Micrium\uCOS-III\Ports\ARM-Cortex-M4; ..\..\..\Micrium\uCOS-III\Ports\ARM-Cortex-M4\Generic\IAR; ..\..\..\Micrium\uCOS-III\Source; ..\BSP\ST; ..\..\..\STM32Cube_FW_F4_V1.9.0\Drivers\STM32F4xx_HAL_Driver\Inc; ..\..\..\STM32Cube_FW_F4_V1.9.0\Drivers\CMSIS\Device\ST\STM32F4xx\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: uCOS-III.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\BSP\IAR\stm32f401xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  group APP
    ./: app.c app_cfg.h Common.h cpu_cfg.h ErrorCodes.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h RoverBody.c RoverBody.h RpcController.c RpcController.h UartController.c UartController.h UserController.c UserController.h
  group BSP
    ../BSP/: bsp.c bsp.h bsp_int.c bsp_periph.c stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_msp.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim.h stm32f4xx_hal_uart.c stm32f4xx_it.c stm32f4xx_nucleo.c system_stm32f4xx.c
    ../BSP/IAR/: cstartup.c
  group Documents
    ../: build history.txt information.txt memo.txt
  group uC/CPU
    ../../../Micrium/uC-CPU/: cpu_core.c
    ../../../../uC-CPU/: cpu_core.h cpu_def.h
  group uC/CPU/ARM-Cortex-M4/IAR
    ../../../../uC-CPU/ARM-Cortex-M4/IAR/: cpu.h
    ../../../Micrium/uC-CPU/ARM-Cortex-M4/IAR/: cpu_a.asm cpu_c.c
  group uC/LIB
    ../../../Micrium/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../../../../uC-LIB/: lib_ascii.h lib_def.h lib_math.h lib_mem.h lib_str.h
  group uC/LIB/Ports/ARM-Cortex-M4/IAR
    ../../../Micrium/uC-LIB/Ports/ARM-Cortex-M4/IAR/: lib_mem_a.asm
  group uC/OS-III/Ports/ARM-Cortex-M4/Generic/IAR
    ../../../../uCOS-III/Ports/ARM-Cortex-M4/Generic/IAR/: os_cpu.h
    ../../../Micrium/uCOS-III/Ports/ARM-Cortex-M4/Generic/IAR/: os_cpu_a.asm os_cpu_c.c
  group uC/OS-III/Source
    ../../../../uCOS-III/Source/: os.h os_type.h
    ../../../Micrium/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
