# IAR project uCOS-III-Ex3.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F40_41xxx
  ICCARM.CCIncludePath2: ; ..\BSP; ..\BSP\IAR; ..\BSP\ST\STM32F4xx\inc; ..\BSP\ST\STM32F4xx\src; ..\..\..\..\uC-CPU; ..\..\..\..\uC-LIB; ..\..\..\..\uC-CPU\ARM-Cortex-M4\IAR; ..\..\..\..\uCOS-III\Ports\ARM-Cortex-M4; ..\..\..\..\uCOS-III\Ports\ARM-Cortex-M4\Generic\IAR; ..\..\..\..\uCOS-III\Source
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: uCOS-III.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkKeepSymbols: __checksum
  ILINK.IlinkIcfFile: ..\BSP\IAR\stm32f411-discovery_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  group APP
    ./: app.c app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group BSP
    ../BSP/: bsp.c bsp.h bsp_int.c bsp_periph.c stm32f401_discovery.c stm32f401_discovery_l3gd20.c system_stm32f4xx.c
    ../BSP/IAR/: cstartup.c
  group BSP/ST/STM32F4xx/inc
    ../BSP/ST/STM32F4xx/inc/: misc.h stm32f4xx_adc.h stm32f4xx_can.h stm32f4xx_crc.h stm32f4xx_cryp.h stm32f4xx_dac.h stm32f4xx_dbgmcu.h stm32f4xx_dcmi.h stm32f4xx_dma.h stm32f4xx_exti.h stm32f4xx_flash.h stm32f4xx_fsmc.h stm32f4xx_gpio.h stm32f4xx_hash.h stm32f4xx_i2c.h stm32f4xx_iwdg.h stm32f4xx_pwr.h stm32f4xx_rcc.h stm32f4xx_rng.h stm32f4xx_rtc.h stm32f4xx_sdio.h stm32f4xx_spi.h stm32f4xx_syscfg.h stm32f4xx_tim.h stm32f4xx_usart.h stm32f4xx_wwdg.h
  group BSP/ST/STM32F4xx/src
    ../BSP/ST/STM32F4xx/src/: misc.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c
  group uC/CPU
    ../../../../uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
  group uC/CPU/ARM-Cortex-M4/IAR
    ../../../../uC-CPU/ARM-Cortex-M4/IAR/: cpu.h cpu_a.asm cpu_c.c
  group uC/LIB
    ../../../../uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
  group uC/LIB/Ports/ARM-Cortex-M4/IAR
    ../../../../uC-LIB/Ports/ARM-Cortex-M4/IAR/: lib_mem_a.asm
  group uC/OS-III/Ports/ARM-Cortex-M4/Generic/IAR
    ../../../../uCOS-III/Ports/ARM-Cortex-M4/Generic/IAR/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group uC/OS-III/Source
    ../../../../uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
